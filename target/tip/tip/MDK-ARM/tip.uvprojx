# Keil uVision project tip.uvprojx, settings and files
target tip (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: tip +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../../artos/artos/inc;..\..\..\..\artos\ashell\inc;..\..\..\..\artos\sysview\inc;../../../../module/driver/inc;../../../../module/protocol/inc;../../../../module/algorithm/inc;../../../../module/task/inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/Driver
    ../../../../module/driver/src/: drv_key.c drv_uart.c drv_bmi088.c drv_exti.c drv_ist8310.c drv_tim.c
  group Application/User/Prot
    ../../../../module/protocol/src/: prot_sbus.c prot_ano.c
  group Application/User/Algo
    ../../../../module/algorithm/src/: algo_attitude_ctrl.c algo_mahony_ahrs.c algo_pid.c algo_remote_ctrl.c
  group Application/User/Task
    ../../../../module/task/src/: task_imu.c task_rc.c task_shell.c
    ../../../../artos/artos/src/: artos.c
  group Middlewares/Artos
    ../../../../artos/artos/src/: cmsis_os2.c croutine.c event.c heap_4.c list.c port.c queue.c stream_buffer.c task.c timer.c
  group Middlewares/Ashell
    ../../../../artos/ashell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group Middlewares/SysView
    ../../../../artos/sysview/src/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_ARTOS.c SEGGER_SYSVIEW_Config_ARTOS.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
